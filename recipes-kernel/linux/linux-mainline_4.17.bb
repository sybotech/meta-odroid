LINUX_VERSION ?= "4.17-rc6"
SRCREV ?= "771c577c23bac90597c685971d7297ea00f99d11"

require linux-mainline.inc

COMPATIBLE_MACHINE = "(odroid-c1|odroid-c2|odroid-xu3|odroid-xu4|odroid-xu3-lite|odroid-hc1)"
